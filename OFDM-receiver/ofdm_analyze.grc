options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: ofdm_analyze
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_length
  id: variable
  parameters:
    value: 1024*4
  states: {}
- name: freq
  id: variable
  parameters:
    value: 4345e5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: thres
  id: variable_qtgui_range
  parameters:
    label: Threshold
    orient: Qt.Horizontal
    start: '-120'
    step: '1'
    stop: '50'
    value: '-75'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(freq)
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
  states: {state: disabled}
- name: inspector_qtgui_sink_vf_0
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: freq
    fft_len: fft_length
    manual: 'False'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.2'
    fft_len: fft_length
    logfile: ''
    min_bw: '5000'
    quant: '0.001'
    samp_rate: samp_rate
    sensitivity: ' 0.2'
    threshold: thres
    window: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '40'
    freq0: freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [iio_pluto_source_0, '0', inspector_signal_detector_cvf_0, '0']
- [inspector_qtgui_sink_vf_0, map_out, blocks_message_debug_0, print]
- [inspector_signal_detector_cvf_0, '0', inspector_qtgui_sink_vf_0, '0']
- [inspector_signal_detector_cvf_0, map_out, inspector_qtgui_sink_vf_0, map_in]
- [rtlsdr_source_0, '0', inspector_signal_detector_cvf_0, '0']

metadata:
  file_format: 1
