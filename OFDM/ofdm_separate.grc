options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: ofdm_separate
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: 32768/8
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '434502850'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '869005700'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: sig
  id: variable
  parameters:
    value: '0'
  states: {}
- name: thres
  id: variable_qtgui_range
  parameters:
    label: Threshold
    orient: Qt.Horizontal
    start: '-120'
    step: '1'
    stop: '50'
    value: '-65'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cutoff
    gain: '1.0'
    samp_rate: samp_rate
    width: cutoff/10
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: int(samp_rate/decimation)
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(freq)
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
  states: {state: disabled}
- name: inspector_qtgui_sink_vf_0
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: freq
    fft_len: fft_length
    manual: 'False'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {state: disabled}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.2'
    fft_len: fft_length
    logfile: ''
    min_bw: '10'
    quant: '0.001'
    samp_rate: samp_rate
    sensitivity: '0.8'
    threshold: thres
    window: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: inspector_signal_extractor_c_0
  id: inspector_signal_extractor_c
  parameters:
    osf: '1'
    rate: '48000'
    resample: 'False'
    signal: '0'
  states: {state: disabled}
- name: inspector_signal_separator_c_0
  id: inspector_signal_separator_c
  parameters:
    file: 'False'
    oversample: '100'
    samp_rate: samp_rate
    taps_file: /home/senpo/src/gr-inspector/apps/taps.json
    trans_width: '0.1'
    window: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: decimation
    fc: freq
    fftsize: fft_length
    label1: Signal  Separator
    label2: Xlating FIR
    name: '"Extracted Signal " + str(sig+1)'
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '40'
    freq0: freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: 1e6
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_null_source_0, '0', qtgui_freq_sink_x_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [inspector_qtgui_sink_vf_0, map_out, inspector_signal_separator_c_0, map_in]
- [inspector_signal_detector_cvf_0, '0', inspector_qtgui_sink_vf_0, '0']
- [inspector_signal_detector_cvf_0, map_out, inspector_qtgui_sink_vf_0, map_in]
- [inspector_signal_extractor_c_0, '0', qtgui_freq_sink_x_0, '1']
- [inspector_signal_separator_c_0, sig_out, inspector_signal_extractor_c_0, sig_in]
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', inspector_signal_detector_cvf_0, '0']
- [rtlsdr_source_0, '0', inspector_signal_separator_c_0, '0']

metadata:
  file_format: 1
