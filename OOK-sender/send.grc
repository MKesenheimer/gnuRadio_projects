options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: send
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier
  id: variable
  parameters:
    value: '915552'
  states: {}
- name: padding
  id: variable
  parameters:
    value: list(np.zeros(32))
  states: {}
- name: payload
  id: variable
  parameters:
    comment: See file generate-payload-file.py how the payload file was generated.
    value: np.load("/Users/kesenheimer/Hacking/SDR/gnuRadio_projects/OOK-sender/payload.npy")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e5
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/433MHz/simulation.complex
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '1250'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: len(payload)+len(padding)
    type: complex
    vector: padding
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: payload
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(433e6)
    samplerate: int(samp_rate)
    type: fc32
    uri: usb:20.25.5
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 433e6
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_insert_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0, '0', blocks_vector_insert_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
