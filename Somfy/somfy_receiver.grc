options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: somfy_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: 4800*4
  states: {}
- name: dfctr1
  id: variable
  parameters:
    value: 19.2e3
  states: {}
- name: dfctr2
  id: variable
  parameters:
    value: '-19.2e3'
  states: {}
- name: dfctr3
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fmid
  id: variable
  parameters:
    value: 868.949e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: OOK_demodulator_improved_0
  id: OOK_demodulator_improved
  parameters:
    fbaud: baud_rate
    freq: dfctr1
    offset: '-0.5'
    re_samp_rate: '96000'
    samp_rate: samp_rate
  states: {}
- name: OOK_demodulator_improved_0_0
  id: OOK_demodulator_improved
  parameters:
    fbaud: baud_rate
    freq: dfctr3
    offset: '0'
    re_samp_rate: '96000'
    samp_rate: samp_rate
  states: {}
- name: OOK_demodulator_improved_0_1
  id: OOK_demodulator_improved
  parameters:
    fbaud: baud_rate
    freq: dfctr2
    offset: '0.5'
    re_samp_rate: '96000'
    samp_rate: samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/io-home/somfy_868.949MHz_2.4Mss.complex
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/Somfy/io_homecontrol_sliced_96k_byte_cx2.raw
    type: float
    vlen: '3'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/Somfy/stdout
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/io-home/somfy_868.949MHz_2.4Mss.complex
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_streams_to_vector_0_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '3'
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: manchester_decode_0
  id: manchester_decode
  parameters:
    bit_mode: '1'
    endianess: '1'
    message_length: '38'
    nsync_symbols: '10'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: fmid
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [OOK_demodulator_improved_0, '0', blocks_streams_to_vector_0_0, '0']
- [OOK_demodulator_improved_0, '0', manchester_decode_0, '0']
- [OOK_demodulator_improved_0, '0', qtgui_time_sink_x_0, '0']
- [OOK_demodulator_improved_0, '1', blocks_null_sink_0, '0']
- [OOK_demodulator_improved_0, '2', qtgui_freq_sink_x_1, '0']
- [OOK_demodulator_improved_0_0, '0', blocks_streams_to_vector_0_0, '1']
- [OOK_demodulator_improved_0_0, '0', qtgui_time_sink_x_0, '1']
- [OOK_demodulator_improved_0_0, '1', blocks_null_sink_0_0_0, '0']
- [OOK_demodulator_improved_0_0, '2', qtgui_freq_sink_x_1, '1']
- [OOK_demodulator_improved_0_1, '0', blocks_streams_to_vector_0_0, '2']
- [OOK_demodulator_improved_0_1, '0', qtgui_time_sink_x_0, '2']
- [OOK_demodulator_improved_0_1, '1', blocks_null_sink_0_0, '0']
- [OOK_demodulator_improved_0_1, '2', qtgui_freq_sink_x_1, '2']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_streams_to_vector_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle_0, '0', OOK_demodulator_improved_0, '0']
- [blocks_throttle_0, '0', OOK_demodulator_improved_0_0, '0']
- [blocks_throttle_0, '0', OOK_demodulator_improved_0_1, '0']
- [manchester_decode_0, '0', blocks_file_sink_1, '0']
- [rtlsdr_source_0, '0', OOK_demodulator_improved_0, '0']
- [rtlsdr_source_0, '0', OOK_demodulator_improved_0_0, '0']
- [rtlsdr_source_0, '0', OOK_demodulator_improved_0_1, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
