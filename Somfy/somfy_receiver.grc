options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: somfy_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: 4800*4
  states: {}
- name: dfctr1
  id: variable
  parameters:
    value: 19.2e3
  states: {}
- name: dfctr2
  id: variable
  parameters:
    value: '-19.2e3'
  states: {}
- name: dfctr3
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fmid
  id: variable
  parameters:
    value: 868.949e6
  states: {}
- name: ifile
  id: variable
  parameters:
    value: '"/Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/Somfy/records/somfy_868.949MHz_2.4Mss.complex"'
  states: {}
- name: ofile
  id: variable
  parameters:
    value: '"/Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/Somfy/payloads/out"'
  states: {}
- name: omega_n_norm
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Normalized Bandwidth
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: 2.0*math.pi*0.25
    value: '0.045'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Expected TED Gain
    orient: Qt.Horizontal
    start: '0.05'
    step: '0.01'
    stop: '5.0'
    value: '1'
  states: {}
- name: zeta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Damping Factor
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '5.0'
    value: '1.0'
  states: {}
- name: OOK_demodulator_improved_0
  id: OOK_demodulator_improved
  parameters:
    fbaud: baud_rate
    freq: dfctr1
    offset: '-0.5'
    re_samp_rate: '96000'
    samp_rate: samp_rate
  states: {}
- name: OOK_demodulator_improved_0_0
  id: OOK_demodulator_improved
  parameters:
    fbaud: baud_rate
    freq: dfctr3
    offset: '-0.01'
    re_samp_rate: '96000'
    samp_rate: samp_rate
  states: {}
- name: OOK_demodulator_improved_0_1
  id: OOK_demodulator_improved
  parameters:
    fbaud: baud_rate
    freq: dfctr2
    offset: '0.5'
    re_samp_rate: '96000'
    samp_rate: samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
    vlen: '3'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/Somfy/io_homecontrol_96k_sliced.raw
    type: float
    vlen: '3'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/Somfy/io_homecontrol_96k_clock_recovery.raw
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: ofile+"_chn1.bin"
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/Somfy/stdout
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: ofile+"_chn3.bin"
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: ofile+"_chn2.bin"
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/Somfy/io_homecontrol_96k_demod.raw
    type: float
    vlen: '3'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_2
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/Somfy/io_homecontrol_96k_filter.raw
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ifile
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_streams_to_vector_0_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '3'
    type: byte
  states: {state: disabled}
- name: blocks_streams_to_vector_0_0_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '3'
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.2'
    init: '0'
    low: '-0.2'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.2'
    init: '0'
    low: '-0.2'
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.2'
    init: '0'
    low: '-0.2'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Original:
      Expected TED Gain: 1
      Loop BW: 45m
      Damping Factor: 1
    damping: zeta
    loop_bw: omega_n_norm
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: ted_gain
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Original:
      Expected TED Gain: 1
      Loop BW: 45m
      Damping Factor: 1
    damping: zeta
    loop_bw: omega_n_norm
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: ted_gain
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Original:
      Expected TED Gain: 1
      Loop BW: 45m
      Damping Factor: 1
    damping: zeta
    loop_bw: omega_n_norm
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: ted_gain
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: extract_payload_0
  id: extract_payload
  parameters:
    bitpattern: (1,0,1,0,1,0,1,0,1,0,1,1,1,1,1,1,1,1,1)
    headerLength: 40*8
    payloadLength: 40*8
  states: {}
- name: extract_payload_0_0
  id: extract_payload
  parameters:
    bitpattern: (1,0,1,0,1,0,1,0,1,0,1,1,1,1,1,1,1,1,1)
    headerLength: 40*8
    payloadLength: 40*8
  states: {}
- name: extract_payload_0_0_0
  id: extract_payload
  parameters:
    bitpattern: (1,0,1,0,1,0,1,0,1,0,1,1,1,1,1,1,1,1,1)
    headerLength: 40*8
    payloadLength: 40*8
  states: {}
- name: fir_filter_xxx_0_1_0_0_0
  id: fir_filter_xxx
  parameters:
    comment: Matched Filter
    decim: '1'
    samp_delay: int((samp_per_sym-1.0)/2.0)+4
    taps: '[1.0/float(samp_per_sym)]*samp_per_sym'
    type: fff
  states: {}
- name: fir_filter_xxx_0_1_0_0_0_0
  id: fir_filter_xxx
  parameters:
    comment: Matched Filter
    decim: '1'
    samp_delay: int((samp_per_sym-1.0)/2.0)+4
    taps: '[1.0/float(samp_per_sym)]*samp_per_sym'
    type: fff
  states: {}
- name: fir_filter_xxx_0_1_0_0_0_0_0
  id: fir_filter_xxx
  parameters:
    comment: Matched Filter
    decim: '1'
    samp_delay: int((samp_per_sym-1.0)/2.0)+4
    taps: '[1.0/float(samp_per_sym)]*samp_per_sym'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,1
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,2
    label1: Soft Bits
    label2: Error
    label3: Instantaneous Period
    label4: Average Period
    marker1: '0'
    name: Symbol Synced Output and Debug
    nconnections: '4'
    size: '256'
    srate: baud_rate
    tr_delay: '0.01'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"time_est"'
    type: float
    update_time: '0.1'
    ymax: samp_per_sym+2
    ymin: '-1.5'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: fmid
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [OOK_demodulator_improved_0, '0', blocks_streams_to_vector_0_0_0, '0']
- [OOK_demodulator_improved_0, '0', fir_filter_xxx_0_1_0_0_0, '0']
- [OOK_demodulator_improved_0, '1', blocks_streams_to_vector_0_0, '0']
- [OOK_demodulator_improved_0, '2', qtgui_freq_sink_x_1, '0']
- [OOK_demodulator_improved_0_0, '0', blocks_streams_to_vector_0_0_0, '1']
- [OOK_demodulator_improved_0_0, '0', fir_filter_xxx_0_1_0_0_0_0, '0']
- [OOK_demodulator_improved_0_0, '1', blocks_streams_to_vector_0_0, '1']
- [OOK_demodulator_improved_0_0, '2', qtgui_freq_sink_x_1, '1']
- [OOK_demodulator_improved_0_1, '0', blocks_streams_to_vector_0_0_0, '2']
- [OOK_demodulator_improved_0_1, '0', fir_filter_xxx_0_1_0_0_0_0_0, '0']
- [OOK_demodulator_improved_0_1, '1', blocks_streams_to_vector_0_0, '2']
- [OOK_demodulator_improved_0_1, '2', qtgui_freq_sink_x_1, '2']
- [blocks_char_to_float_0, '0', blocks_file_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_char_0, '0', extract_payload_0, '0']
- [blocks_float_to_char_0_0, '0', extract_payload_0_0, '0']
- [blocks_float_to_char_0_0_0, '0', extract_payload_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_file_sink_0_0_0_0_0_1, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_file_sink_0_0_0_0_0_1_0, '0']
- [blocks_streams_to_vector_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_streams_to_vector_0_0_0, '0', blocks_file_sink_0_0_0_0_1, '0']
- [blocks_threshold_ff_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_float_to_char_0_0_0, '0']
- [blocks_throttle_0, '0', OOK_demodulator_improved_0, '0']
- [blocks_throttle_0, '0', OOK_demodulator_improved_0_0, '0']
- [blocks_throttle_0, '0', OOK_demodulator_improved_0_1, '0']
- [digital_symbol_sync_xx_0_0, '0', blocks_threshold_ff_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0_0, '1', qtgui_time_sink_x_0_0_0_0_0, '1']
- [digital_symbol_sync_xx_0_0, '2', qtgui_time_sink_x_0_0_0_0_0, '2']
- [digital_symbol_sync_xx_0_0, '3', qtgui_time_sink_x_0_0_0_0_0, '3']
- [digital_symbol_sync_xx_0_0_0, '0', blocks_threshold_ff_0_0, '0']
- [digital_symbol_sync_xx_0_0_0_0, '0', blocks_threshold_ff_0_0_0, '0']
- [extract_payload_0, '0', blocks_repack_bits_bb_0, '0']
- [extract_payload_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [extract_payload_0_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [fir_filter_xxx_0_1_0_0_0, '0', blocks_file_sink_0_0_0_0_2, '0']
- [fir_filter_xxx_0_1_0_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [fir_filter_xxx_0_1_0_0_0_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [fir_filter_xxx_0_1_0_0_0_0_0, '0', digital_symbol_sync_xx_0_0_0_0, '0']
- [rtlsdr_source_0, '0', OOK_demodulator_improved_0, '0']
- [rtlsdr_source_0, '0', OOK_demodulator_improved_0_0, '0']
- [rtlsdr_source_0, '0', OOK_demodulator_improved_0_1, '0']

metadata:
  file_format: 1
