options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/dab_receiver/iq_dab.dat
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '32'
    type: byte
  states: {state: disabled}
- name: dab_dabplus_audio_decoder_ff_0
  id: dab_dabplus_audio_decoder_ff
  parameters:
    address: '234'
    bit_rate: '112'
    dab_mode: '1'
    output_float: 'True'
    protection: '2'
    samp_rate: samp_rate
    subch_size: '84'
  states: {}
- name: dab_fic_decode_0
  id: dab_fic_decode
  parameters:
    dab_mode: '1'
    print_channel_info: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: dab_ofdm_demod_0
  id: dab_ofdm_demod
  parameters:
    autocorr_sr: 'True'
    correct_ffe: 'True'
    dab_mode: '1'
    eq_mag: 'True'
    input_fft: 'True'
    ppm_error: '0'
    samp_rate: samp_rate
    soft_bits: soft
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: |-
      1. Set frequency in USRP
      2. Run flowgraph and read fib_sink info in the console to get the DAB+ Decoder info
      3. Set the DAB+ Decoder info and restart flowgraph
      4. Adjust sampling rate
    note: 'Instructions:'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: '201072000'
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: '208064000'
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain_slider
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_vector_to_stream_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_null_sink_0_1, '0']
- [dab_dabplus_audio_decoder_ff_0, '0', audio_sink_0, '0']
- [dab_dabplus_audio_decoder_ff_0, '1', audio_sink_0, '1']
- [dab_fic_decode_0, '0', blocks_vector_to_stream_0_1, '0']
- [dab_ofdm_demod_0, '0', blocks_vector_to_stream_0, '0']
- [dab_ofdm_demod_0, '0', dab_dabplus_audio_decoder_ff_0, '0']
- [dab_ofdm_demod_0, '0', dab_fic_decode_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', qtgui_const_sink_x_1, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', dab_ofdm_demod_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', dab_ofdm_demod_0, '0']

metadata:
  file_format: 1
