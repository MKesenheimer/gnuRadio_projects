options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ook_transmit
    output_language: python
  states: {}

blocks:
- name: bits_per_pack
  id: variable
  parameters:
    value: '2'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '314980000'
  states: {}
- name: padding
  id: variable
  parameters:
    value: 400*"\x00"
  states: {}
- name: padding_bytes
  id: variable
  parameters:
    value: '[ord(i) for i in padding]'
  states: {}
- name: payload
  id: variable
  parameters:
    value: str("\x84\x21\x08\x42\x10\x84\x21\x08\x42\x10\xee\x84\x21\x08\x42")
  states: {}
- name: payload_bytes
  id: variable
  parameters:
    value: '[ord(i) for i in payload]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(payload_bytes) + len(padding_bytes), payload_bytes + padding_bytes))
    period: '1000'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samples_per_symbol)
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samples_per_symbol
    type: float
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: carrier_freq
    samplerate: int(samp_rate)
    type: fc32
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: len(payload)+len(padding)
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samples_per_symbol)
    taps: '1'
    type: fff
  states: {}

connections:
- [blocks_float_to_complex_0, '0', iio_pluto_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, pdu_pdu_to_stream_x_0, pdus]
- [blocks_moving_average_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_uchar_to_float_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_moving_average_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
