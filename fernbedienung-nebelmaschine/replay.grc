options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: replay
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '313980000'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: freq_span
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.1'
    stop: '10'
    value: '3.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e7
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-40'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: dump.raw
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: replay_10Msps.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: simulated_10Msps.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.complex_band_pass(1, samp_rate, freq_offset - freq_span /  2, freq_offset + freq_span /  2, freq_offset)
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: int(samp_rate)
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    bandwidth: samp_rate
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: freq
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', fir_filter_xxx_0, '0']
- [blocks_file_source_0_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
