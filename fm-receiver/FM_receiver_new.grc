options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: Freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '80000000'
    step: '1000000'
    stop: '100000000'
    value: '90000000'
  states: {}
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: Freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
