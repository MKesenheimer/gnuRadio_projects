options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: ford_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '433930000'
  states: {}
- name: freq_offset_chan0
  id: variable
  parameters:
    value: '-330000'
  states: {}
- name: freq_offset_chan1
  id: variable
  parameters:
    value: '330000'
  states: {}
- name: freq_spread
  id: variable
  parameters:
    comment: Distance of the two frequencies
    value: '20000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: freq_spread*2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-40'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_threshold
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_threshold
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Simulation-Received_Ford_433.93MHz_1Msps.raw
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: payload_chan0.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: decoded_chan0.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: decoded_chan1.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: manchester_chan0.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: payload_chan1.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/ford_s-max-radio/Simulation_Ford_433.93MHz_1Msps.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_3
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: demod.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate/2)
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '15'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '15'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: extract_payload_0
  id: extract_payload
  parameters:
    bitpattern: (0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,0,1,1,0,1)
    headerLength: '200'
    lengthTagKey: packet_len
    payloadLength: '218'
    prependHeader: 'True'
  states: {}
- name: extract_payload_0_0
  id: extract_payload
  parameters:
    bitpattern: (0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,0,1,1,0,1)
    headerLength: '200'
    lengthTagKey: packet_len
    payloadLength: '218'
    prependHeader: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_chan0
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, freq_spread/2, freq_spread)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_chan1
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, freq_spread/2, freq_spread)
    type: ccf
  states: {}
- name: manchester_decode_0
  id: manchester_decode
  parameters:
    bit_mode: '0'
    endianess: '0'
    nsync_symbols: '0'
    samples_per_symbol: '2'
    type: byte
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: 'Alternative: xxd -b decoded.bin| awk ''{print $2$3$4$5$6$7}'' | tr -d ''\n'' | awk ''{ while (match($0, /01010101010101011001010101/)) { print substr($0, RSTART, 240); $0 = substr($0, RSTART + 1); } }'' | perl -lape ''$_=unpack"H*",pack"B*",$_'''
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: int(samp_rate/2)
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '20'
    ymin: '-20'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '2'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '2'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_file_sink_0_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_file_sink_0_0_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_0_1_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_0_2, '0', blocks_file_sink_0_0_0_0_0_1, '0']
- [blocks_repack_bits_bb_0_3, '0', blocks_file_sink_0_0_0_0_0_0_1, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_binary_slicer_fb_0, '0', extract_payload_0, '0']
- [digital_binary_slicer_fb_0, '0', manchester_decode_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', extract_payload_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_time_sink_x_0, '1']
- [extract_payload_0, '0', blocks_repack_bits_bb_0, '0']
- [extract_payload_0, '1', blocks_repack_bits_bb_0_1, '0']
- [extract_payload_0_0, '0', blocks_repack_bits_bb_0_2, '0']
- [extract_payload_0_0, '1', blocks_repack_bits_bb_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [manchester_decode_0, '0', blocks_repack_bits_bb_0_3, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, log]
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0, log]
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_wavfile_sink_0, '1']
- [rational_resampler_xxx_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
