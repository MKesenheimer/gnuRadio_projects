options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: ford_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '433930000'
  states: {}
- name: freq_offset_chan0
  id: variable
  parameters:
    value: '-330000'
  states: {}
- name: freq_offset_chan1
  id: variable
  parameters:
    value: '330000'
  states: {}
- name: freq_spread
  id: variable
  parameters:
    comment: Distance of the two frequencies
    value: '20000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: freq_spread*2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-40'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_threshold
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_threshold
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Matthias-open3_Ford_433.93MHz_1Msps.raw
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: payload_chan0.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: payload_chan1.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: decoded_chan1.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: decoded_chan0.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Sarah-open_Ford_433.93MHz_1Msps.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_1_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_1_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: demod.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate/2)
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '15'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '15'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nPaylaod logger\n\"\"\"\n\n#  epy_block_0.py\n#  created 10/17/2019\n\nfrom gnuradio import gr\nimport pmt\nimport time\n\nclass fsk_message_sync_block(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name = \"Payload logger\",\n            in_sig = None,\n            out_sig = None)\n        self.message_port_register_in(pmt.intern('message'))\n        self.set_msg_handler(pmt.intern('message'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        buff = pmt.to_python(pmt.cdr(msg))\n        print(\"-> Received:\")\n        #print(\"payload: \", end=\"\")\n        #print(\"\".join(\"{:02x}\".format(i) for i in buff))\n        payload = \"\\\\x\" + \"\\\\x\".join(\"{:02x}\".format(i) for i in buff)\n        header = 24 * \"\\\\x55\"\n        frame = header + payload\n        print(\"frame: {}\".format(frame))\n            "
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Manchester decode
      """

      #  epy_block_0.py
      #  created 10/17/2019

      from gnuradio import gr
      import pmt
      import time

      class fsk_message_sync_block(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Manchester decode",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('msg'))
              self.message_port_register_out(pmt.intern('msg'))
              self.set_msg_handler(pmt.intern('msg'), self.handle_msg)

          def access_bit(self, data, num):
              base = int(num // 8)
              shift = int(num % 8)
              return (data[base] >> shift) & 0x1

          def observe_edge(self, first, second):
              if first < second:
                  return 0
              if first > second:
                  return 1

          def handle_msg(self, msg):
              buff = pmt.to_python(pmt.cdr(msg))
              #print("-> Received:")
              #print("bits ({}): ".format(len(buff)), end="")
              #print("".join("{}".format(i) for i in buff))
              #manchester = [self.observe_edge(buff[i], buff[i+1]) for i in range(0, len(buff), 2)]
              l = len(buff)
              l = l - 1 if l % 2 else l # makes length even by subtracting 1 if odd
              manchester = []
              for i in range(0, l, 2):
                  if (a := self.observe_edge(buff[i], buff[i+1])) is not None: manchester.append(a)
              #print("manchester: ", end="")
              #print("".join("{}".format(i) for i in manchester))
              msg = pmt.cons(pmt.string_to_symbol("frame"), pmt.to_pmt(manchester))
              self.message_port_pub(pmt.intern('msg'), msg)
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Manchester decode
      """

      #  epy_block_0.py
      #  created 10/17/2019

      from gnuradio import gr
      import pmt
      import time

      class fsk_message_sync_block(gr.sync_block):
          def __init__(self, sync_word = (0,1,1,1,1,1,1,1,1)):
              gr.sync_block.__init__(self,
                  name = "Extract payload",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('msg'))
              self.message_port_register_out(pmt.intern('bits'))
              self.message_port_register_out(pmt.intern('bytes'))
              self.set_msg_handler(pmt.intern('msg'), self.handle_msg)
              self.sync_word = list(sync_word)

          def find_list_position(self, main_list, sublist):
              try:
                  position = -1
                  while True:
                      position = main_list.index(sublist[0], position + 1)
                      if main_list[position:position + len(sublist)] == sublist:
                          return position
              except ValueError:
                  return -1

          def handle_msg(self, msg):
              buff = pmt.to_python(pmt.cdr(msg))
              #print(buff)
              #print(buff.index(self.sync_word))
              pos = self.find_list_position(buff, self.sync_word)
              payload = buff[pos + len(self.sync_word):]
              msg = pmt.cons(pmt.string_to_symbol("payload"), pmt.to_pmt(payload))
              self.message_port_pub(pmt.intern('bits'), msg)
              byte_array = [int("".join(map(str, payload[i:i+8])), 2) for i in range(0, len(payload), 8)]
              byte_str = "".join("{:02x}".format(i) for i in byte_array)
              msg = pmt.cons(pmt.string_to_symbol("payload"), pmt.to_pmt(byte_str))
              self.message_port_pub(pmt.intern('bytes'), msg)
    sync_word: (0,1,1,1,1,1,1,1,1)
  states: {}
- name: extract_payload_0
  id: extract_payload
  parameters:
    bitpattern: (1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,0,1,1,0,1)
    headerLength: '200'
    lengthTagKey: packet_len
    payloadLength: '208'
    prependHeader: 'True'
  states: {}
- name: extract_payload_0_0
  id: extract_payload
  parameters:
    bitpattern: (1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,0,1,1,0,1)
    headerLength: '200'
    lengthTagKey: packet_len
    payloadLength: '208'
    prependHeader: 'True'
  states: {}
- name: extract_payload_0_1
  id: extract_payload
  parameters:
    bitpattern: (0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,0,1,1,0,1)
    headerLength: '200'
    lengthTagKey: packet_len
    payloadLength: '208'
    prependHeader: 'True'
  states: {}
- name: extract_payload_0_1_0
  id: extract_payload
  parameters:
    bitpattern: (0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,0,1,1,0,1)
    headerLength: '200'
    lengthTagKey: packet_len
    payloadLength: '208'
    prependHeader: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_chan0
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, freq_spread/2, freq_spread)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_chan1
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, freq_spread/2, freq_spread)
    type: ccf
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Alternative: 
      xxd -b decoded_chan0.bin | \
      awk '{print $2$3$4$5$6$7}' | tr -d '\n' | \
      awk '{ while (match($0, /01010101010101010101010101001101/)) \
      { print substr($0, RSTART, 240); $0 = substr($0, RSTART + 1); } }' | \
      perl -lape '$_=unpack"H*",pack"B*",$_'
    note: 'Alternative: xxd -b decoded_chan0.bin | awk ''{print $2$3$4$5$6$7}'' | tr -d ''\n'' | awk ''{ while (match($0, /01010101010101010101010101001101/)) { print substr($0, RSTART, 240); $0 = substr($0, RSTART + 1); } }'' | perl -lape ''$_=unpack"H*",pack"B*",$_'''
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_1_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: int(samp_rate/2)
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '20'
    ymin: '-20'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '2'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '2'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_file_sink_0_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_file_sink_0_0_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0_0, '0', blocks_file_sink_0_0_0_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_1_1, '0', pdu_tagged_stream_to_pdu_0_1, '0']
- [blocks_repack_bits_bb_0_1_1_0, '0', pdu_tagged_stream_to_pdu_0_1_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_repack_bits_bb_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', extract_payload_0, '0']
- [digital_binary_slicer_fb_0, '0', extract_payload_0_1, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', extract_payload_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', extract_payload_0_1_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_time_sink_x_0, '1']
- [epy_block_0_0, msg, epy_block_0_0_0, msg]
- [epy_block_0_0_0, bits, blocks_message_debug_0, log]
- [epy_block_0_0_0, bytes, blocks_message_debug_0, log]
- [extract_payload_0, '0', blocks_null_sink_0, '0']
- [extract_payload_0, '1', pdu_tagged_stream_to_pdu_0_0_0_0, '0']
- [extract_payload_0_0, '0', blocks_null_sink_0_0, '0']
- [extract_payload_0_0, '1', pdu_tagged_stream_to_pdu_0_0_0_0_0, '0']
- [extract_payload_0_1, '0', blocks_repack_bits_bb_0, '0']
- [extract_payload_0_1, '1', blocks_repack_bits_bb_0_1_1, '0']
- [extract_payload_0_1_0, '0', blocks_repack_bits_bb_0_0, '0']
- [extract_payload_0_1_0, '1', blocks_repack_bits_bb_0_1_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, blocks_message_debug_0, log]
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, epy_block_0_0, msg]
- [pdu_tagged_stream_to_pdu_0_0_0_0_0, pdus, epy_block_0_0, msg]
- [pdu_tagged_stream_to_pdu_0_1, pdus, epy_block_0, message]
- [pdu_tagged_stream_to_pdu_0_1_0, pdus, epy_block_0, message]
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_wavfile_sink_0, '1']
- [rational_resampler_xxx_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
