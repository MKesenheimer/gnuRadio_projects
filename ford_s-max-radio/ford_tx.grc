options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: ford_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bits_per_second
  id: variable
  parameters:
    value: '4166'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '433930000'
  states: {}
- name: freq_offset_chan0
  id: variable
  parameters:
    value: '-330000'
  states: {}
- name: freq_spread
  id: variable
  parameters:
    comment: Distance of the two frequencies
    value: '20000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2 * math.pi * freq_spread
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: 2 * math.pi * (freq_offset_chan0 - freq_spread / 2)/sensitivity
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Simulation_Ford_433MHz_10Msps.raw
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      mkfifo stdin
      echo "Hello World" > stdin
    file: stdin
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2 * math.pi * freq_spread/sensitivity
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/bits_per_second)
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: sensitivity
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, freq_offset_chan0 - freq_spread*4, freq_offset_chan0 + freq_spread*4, freq_spread*2)
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, samp_rate/2, freq_spread*2)
    type: fcf
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: echo "Hello World" | nc 127.0.0.1 2000 -
    port: '2000'
    server: 'True'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '32'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_vco_f_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_vco_f_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_vco_f_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', soapy_hackrf_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', soapy_hackrf_sink_0, '0']
- [network_tcp_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
