options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: ford_tx_freq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bits_per_second
  id: variable
  parameters:
    value: '4166'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '433930000'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '330000'
  states: {}
- name: freq_spread
  id: variable
  parameters:
    comment: Distance of the two fsk frequencies
    value: '20000'
  states: {}
- name: payload
  id: variable
  parameters:
    value: str("\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x35\x55\x4c\xb5\x2b\x34\xb4\xb3\x2d\x4b\x2b\x53\x4a\xab\x32\xaa\xb2\xb5\x2c\xd2\xd3\x54\xab\x52\xb5\x4b\x41\xff")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2 * math.pi * freq_spread
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-freq_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: 2 * math.pi * (- freq_spread / 2) / sensitivity
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 2 * math.pi * (- freq_spread / 2) / sensitivity
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Simulation_Ford_433.93MHz_10Msps.raw
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2 * math.pi * freq_spread / sensitivity
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2 * math.pi * freq_spread / sensitivity
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/bits_per_second)
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/bits_per_second)
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(samp_rate/bits_per_second) * 8
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(samp_rate/bits_per_second) * 8
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: int(samp_rate/bits_per_second) * 8
    lengthtagname: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: int(samp_rate/bits_per_second) * 8
    lengthtagname: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: "sensitivity\t\t"
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: "sensitivity\t\t"
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Synchronized fsk message block
      """

      #  epy_block_0.py
      #  created 10/17/2019

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      run = 1

      class fsk_message_sync_block(gr.sync_block):
          def __init__(self, payload: str = "", period: int = 1000, pause: int = 50):
              gr.sync_block.__init__(self,
                  name = "Synchronized FSK message block",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_out(pmt.intern('chan1'))
              self.message_port_register_out(pmt.intern('chan0'))
              self.payload = payload
              self.period = period
              self.pause = pause

          def start(self):
              self.x = threading.Thread(target=self.run, args=())
              print("Starting FSK payload generation thread")
              self.x.start()

          def stop(self):
              print("Stopping FSK payload generation thread")
              global run
              run = 0
              self.x.join()
              return True

          def send_payload(self, chan):
              payload_bytes = [ord(i) for i in self.payload]
              payload_msg = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(payload_bytes), payload_bytes))
              self.message_port_pub(pmt.intern(chan), payload_msg)

          def run(self):
              global run
              while run:
                  self.send_payload('chan0')
                  time.sleep(self.pause / 1000)
                  self.send_payload('chan1')
                  time.sleep(self.pause / 1000)
                  self.send_payload('chan0')
                  time.sleep(self.period / 1000)
    pause: '1000'
    payload: payload
    period: '5000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: echo "Hello World" | nc 127.0.0.1 2000 -
    host: 127.0.0.1
    mtu: '100'
    port: '2000'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    comment: echo "Hello World" | nc 127.0.0.1 2000 -
    host: 127.0.0.1
    mtu: '100'
    port: '2001'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {state: disabled}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '30'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: chan0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: chan1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: chan0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: chan1
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', virtual_sink_0_0, '0']
- [blocks_repeat_0, '0', blocks_vco_c_0, '0']
- [blocks_repeat_0_0, '0', blocks_vco_c_0_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_1_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_1_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_tagged_stream_mux_0, '0', qtgui_sink_x_0, '0']
- [blocks_tagged_stream_mux_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vco_c_0_0, '0', blocks_multiply_xx_0_0, '0']
- [epy_block_0, chan0, pdu_pdu_to_stream_x_0, pdus]
- [epy_block_0, chan0, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_0, chan1, pdu_pdu_to_stream_x_0_0, pdus]
- [epy_block_0, chan1, pdu_pdu_to_tagged_stream_0_0, pdus]
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [network_socket_pdu_0_0, pdus, pdu_pdu_to_tagged_stream_0_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [pdu_pdu_to_stream_x_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', qtgui_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', soapy_hackrf_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, pdu_pdu_to_tagged_stream_1, pdus]
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0, log]
- [pdu_tagged_stream_to_pdu_0_0, pdus, pdu_pdu_to_tagged_stream_1, pdus]
- [virtual_source_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [virtual_source_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [virtual_source_0_0, '0', blocks_stream_to_tagged_stream_1_0, '0']
- [virtual_source_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
