options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: FSK
    output_language: python
    title: FSK 2-channel TX
  states: {}

blocks:
- name: bits_per_second
  id: variable
  parameters:
    value: '4300'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '433930000'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '330000'
  states: {}
- name: freq_spread
  id: variable
  parameters:
    comment: Distance of the two fsk frequencies
    value: '20000'
  states: {}
- name: padding
  id: variable
  parameters:
    value: 16 * "\xff"
  states: {}
- name: payload
  id: variable
  parameters:
    comment: default payload
    value: str("\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x55\x4D\x55\x53\x2D\x4A\xCD\x2D\x2C\xCB\x4D\x2B\x35\x52\xAA\xCB\x55\x55\x4B\x2D\x32\xD3\x52\xCA\xD5\x53\x32\xB0")
  states: {}
- name: payload_bytes
  id: variable
  parameters:
    value: '[ord(i) for i in payload]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samples_per_packet
  id: variable
  parameters:
    value: int(samp_rate/bits_per_second) * 8 * len(payload)
  states: {}
- name: samples_per_padding
  id: variable
  parameters:
    value: int(samp_rate/bits_per_second) * 8 * len(padding)
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2 * math.pi * freq_spread
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: 2 * math.pi * (- freq_spread / 2) / sensitivity
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(payload_bytes), payload_bytes))
    period: '1000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2 * math.pi * freq_spread / sensitivity
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/bits_per_second)
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    comment: Add padding after frame
    lengths: (samples_per_packet + samples_per_padding, samples_per_padding)
    type: complex
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    comment: Add padding before frame
    lengths: (samples_per_padding, samples_per_packet)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: samples_per_packet
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: "sensitivity\t\t"
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      FSK channelizer
      """

      #  epy_block_0.py
      #  created 10/17/2019

      from gnuradio import gr
      import pmt
      import time

      class fsk_message_sync_block(gr.sync_block):
          def __init__(self, freq_offset: int = 0, pause: int = 50):
              gr.sync_block.__init__(self,
                  name = "FSK channelizer",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('trigger'))
              self.message_port_register_out(pmt.intern('freq'))
              self.message_port_register_out(pmt.intern('payload'))
              self.set_msg_handler(pmt.intern('trigger'), self.handle_msg)
              self.freq_offset = freq_offset
              self.pause = pause

          def send_payload(self, payload_msg, freq_offset):
              freq_msg = pmt.dict_add(pmt.make_dict(), pmt.intern("freq"), pmt.from_double(freq_offset))
              self.message_port_pub(pmt.intern('freq'), freq_msg)
              self.message_port_pub(pmt.intern('payload'), payload_msg)

          def run(self, payload):
              self.send_payload(payload, self.freq_offset)
              time.sleep(self.pause / 1000)
              self.send_payload(payload, -self.freq_offset)
              time.sleep(self.pause / 1000)
              self.send_payload(payload, self.freq_offset)
              time.sleep(self.pause / 1000)

          def handle_msg(self, msg):
              payload = pmt.to_python(pmt.cdr(msg))
              print("-> Sending:")
              print("".join("{:02x}".format(i) for i in payload))
              self.run(msg)
    freq_offset: freq_offset
    pause: '190'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: echo "<payload>" | nc 127.0.0.1 2000 -
    host: 127.0.0.1
    mtu: '100'
    port: '2000'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: len(payload)
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data0
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, log]
- [blocks_message_strobe_0, strobe, epy_block_0, trigger]
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '1']
- [blocks_null_source_0_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_repeat_0, '0', blocks_vco_c_0, '0']
- [blocks_stream_mux_0, '0', qtgui_sink_x_0, '0']
- [blocks_stream_mux_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [epy_block_0, freq, analog_sig_source_x_0, cmd]
- [epy_block_0, payload, pdu_pdu_to_stream_x_0, pdus]
- [network_socket_pdu_0, pdus, blocks_message_debug_0, log]
- [network_socket_pdu_0, pdus, epy_block_0, trigger]
- [pdu_pdu_to_stream_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
