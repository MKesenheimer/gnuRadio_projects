options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: nrz_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: payload
  id: variable
  parameters:
    value: (1, 0, 1, 0, 1, 0, 1, 0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: nrz.bin
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: len(payload)
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: payload
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_NRZI
    modulus: '2'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {state: disabled}

connections:
- [blocks_repack_bits_bb_0_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_throttle2_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_vector_source_x_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_vector_source_x_0, '0', satellites_nrzi_decode_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, log]
- [satellites_nrzi_decode_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
