options:
  parameters:
    generate_options: qt_gui
    id: pluto_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f0
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 100e6
    step: 10e6
    stop: 2000e6
    value: 1023e5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(1e6)
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(f0)
    gain1: '''manual'''
    manual_gain1: '74.5'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    uri: usb:20.11.5
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
