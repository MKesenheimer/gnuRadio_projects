options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: pluto_fm_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: freq_0
  id: variable
  parameters:
    value: 94.3e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 576e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(samp_rate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(samp_rate)
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/kesenheimer/Documents/Basteln/SDR/gnuRadio_projects/pluto_fm_transmitter/Geburtstags_Polka.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(freq_0)
    samplerate: int(samp_rate)
    uri: usb:20.19.5
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(audio_rate)
    interp: int(samp_rate)
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_tx_0, '0', iio_pluto_sink_0, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
