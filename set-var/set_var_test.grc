options:
  parameters:
    author: kesenheimer
    generate_options: qt_gui
    id: set_var_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_offset
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_toggle_button_msg_0
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_offset
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    comment: echo "Hello World" | nc 127.0.0.1 2001 -
    host: 127.0.0.1
    mtu: '100'
    port: '2001'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [network_socket_pdu_0_0, pdus, blocks_message_debug_0, log]
- [network_socket_pdu_0_0, pdus, blocks_msgpair_to_var_0, inpair]
- [variable_qtgui_toggle_button_msg_0, state, blocks_message_debug_0, log]
- [variable_qtgui_toggle_button_msg_0, state, blocks_msgpair_to_var_0, inpair]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
