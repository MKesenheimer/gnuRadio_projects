options:
  parameters:
    author: kesenheimer
    generate_options: no_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '640'
    fps: '0'
    height: '480'
    type: byte
    width: '640'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle2_1, '0']
- [blocks_throttle2_1, '0', video_sdl_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
